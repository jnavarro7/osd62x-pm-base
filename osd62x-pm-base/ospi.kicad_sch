File: osd62x-pm-base/ospi.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Unit I created
Parts:
- added U1: ~, symbol octavo_Library:osd62x-pm
